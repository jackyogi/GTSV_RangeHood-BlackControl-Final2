<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GTSV-BlackControl.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\Download Docs\stsw-stm32077STM32L1xx standard peripherals library\STM32L1xx_StdPeriph_Lib_V1.2.0\Project\STM32L1xx_StdPeriph_Templates\EWARM\Project.ewp</path>
  </project>
  <batchBuild/>
</workspace>


